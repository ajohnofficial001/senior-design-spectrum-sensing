options:
  parameters:
    author: Senior Design team
    description: Finite four-scenario simulation. No SDRs. Local mock ledger only.
    generate_options: no_gui
    id: full_simulation_calibrated
    output_language: python
    title: Calibrated two-node sensing - INDEPENDENT SEED
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: segment_samples
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: cycles
  id: variable
  parameters:
    value: '100'
  states: {}
- name: tone_offset
  id: variable
  parameters:
    value: '400000'
  states: {}
- name: signal_amplitude
  id: variable
  parameters:
    value: '0.0002'
  states: {}
- name: interference_offset
  id: variable
  parameters:
    value: '600000'
  states: {}
- name: interference_amplitude
  id: variable
  parameters:
    value: '0.002'
  states: {}
- name: node2_gain
  id: variable
  parameters:
    value: '0.65'
  states: {}
- name: noise1
  id: variable
  parameters:
    value: '0.001'
  states: {}
- name: noise2
  id: variable
  parameters:
    value: '0.0012'
  states: {}
- name: seed
  id: variable
  parameters:
    value: '1001'
  states: {}
- name: window_samples
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: power_scale
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: threshold1
  id: variable
  parameters:
    value: '0.04954833164811134'
  states: {}
- name: threshold2
  id: variable
  parameters:
    value: '0.07464989274740219'
  states: {}
- name: fusion_rule
  id: variable
  parameters:
    value: '''OR'''
  states: {}
- name: taps
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, 20000, 10000)
  states: {}
- name: guard_samples
  id: variable
  parameters:
    value: len(taps) + window_samples
  states: {}
- name: output_root
  id: variable
  parameters:
    value: '''simulation/generated'''
  states: {}
- name: run_config
  id: variable
  parameters:
    value: '{''expected_samples'': 4 * segment_samples * cycles, ''cycles'': cycles, ''tone_offset'': tone_offset, ''signal_amplitude'': signal_amplitude, ''interference_offset'': interference_offset, ''interference_amplitude'': interference_amplitude, ''node2_gain'': node2_gain, ''noise1'': noise1, ''noise2'': noise2, ''seed'': seed, ''power_scale'': power_scale, ''filter_taps'': list(taps), ''noise_definition'': ''independent I/Q standard deviation'', ''scenario_order'': [''noise_only'', ''wanted'', ''interferer_only'', ''wanted_and_interferer''], ''calibration_sha256'': ''555296bac58c13081ea6fbde75e63296a8087ec58e05d97428ab9f9f9d503e7e''}'
  states: {}
- name: scenario_source
  id: epy_block
  parameters:
    _source_code: |
      # SPDX-License-Identifier: GPL-3.0
      """Source code also embedded in full_simulation.grc; no device access."""
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Finite two-node scenario source. Ports: RX1 complex, RX2 complex, truth float."""

          def __init__(self, sample_rate=2000000, segment_samples=20000, cycles=10,
                       tone_offset=400000, signal_amplitude=0.0002,
                       interference_offset=600000, interference_amplitude=0.002,
                       node2_gain=0.65, noise1=0.001, noise2=0.0012, seed=101):
              gr.sync_block.__init__(self, name='Finite two-node scenarios', in_sig=None,
                                     out_sig=[np.complex64, np.complex64, np.float32])
              if sample_rate <= 0 or segment_samples < 1 or cycles < 1:
                  raise ValueError('Positive sample rate, segment length and cycles required')
              if max(abs(tone_offset), abs(interference_offset)) >= sample_rate / 2:
                  raise ValueError('Tone and interference offsets must be below Nyquist')
              if min(signal_amplitude, interference_amplitude, node2_gain, noise1, noise2) < 0:
                  raise ValueError('Amplitudes and gains must be nonnegative')
              self.fs = float(sample_rate)
              self.segment = int(segment_samples)
              self.total = self.segment * 4 * int(cycles)
              self.offset, self.amplitude = tone_offset, signal_amplitude
              self.interference_offset = interference_offset
              self.interference_amplitude = interference_amplitude
              self.gain2 = node2_gain
              self.noise = (noise1, noise2)
              self.rng = (np.random.default_rng(int(seed)), np.random.default_rng(int(seed) + 1))
              self.position = 0

          def work(self, input_items, output_items):
              n = min(len(output_items[0]), self.total - self.position)
              if n <= 0:
                  return -1
              index = np.arange(self.position, self.position + n, dtype=np.int64)
              scenario = (index // self.segment) % 4
              occupied = (scenario % 2).astype(np.float32)
              interferer_on = scenario >= 2
              wanted = self.amplitude * occupied * np.exp(2j * np.pi * self.offset * index / self.fs)
              unwanted = self.interference_amplitude * interferer_on * np.exp(
                  2j * np.pi * self.interference_offset * index / self.fs)
              for node, gain in enumerate((1.0, self.gain2)):
                  # Interleaved I/Q draws give identical samples across scheduler chunk sizes.
                  iq = self.rng[node].standard_normal((n, 2)) * self.noise[node]
                  output_items[node][:n] = gain * (wanted + unwanted) + iq[:, 0] + 1j * iq[:, 1]
              output_items[2][:n] = occupied
              self.position += n
              return n
    sample_rate: samp_rate
    segment_samples: segment_samples
    cycles: cycles
    tone_offset: tone_offset
    signal_amplitude: signal_amplitude
    interference_offset: interference_offset
    interference_amplitude: interference_amplitude
    node2_gain: node2_gain
    noise1: noise1
    noise2: noise2
    seed: seed
  states: {}
- name: rx1_filter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tone_offset
    decim: '1'
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: rx1_filtered_mag2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: rx1_filtered_average
  id: blocks_moving_average_xx
  parameters:
    length: window_samples
    max_iter: '4000'
    scale: 1.0/window_samples
    type: float
  states: {}
- name: rx1_filtered_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: power_scale
    type: float
  states: {}
- name: rx1_full_mag2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: rx1_full_average
  id: blocks_moving_average_xx
  parameters:
    length: window_samples
    max_iter: '4000'
    scale: 1.0/window_samples
    type: float
  states: {}
- name: rx1_full_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: power_scale
    type: float
  states: {}
- name: rx2_filter
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tone_offset
    decim: '1'
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: rx2_filtered_mag2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: rx2_filtered_average
  id: blocks_moving_average_xx
  parameters:
    length: window_samples
    max_iter: '4000'
    scale: 1.0/window_samples
    type: float
  states: {}
- name: rx2_filtered_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: power_scale
    type: float
  states: {}
- name: rx2_full_mag2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: rx2_full_average
  id: blocks_moving_average_xx
  parameters:
    length: window_samples
    max_iter: '4000'
    scale: 1.0/window_samples
    type: float
  states: {}
- name: rx2_full_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: power_scale
    type: float
  states: {}
- name: fusion_logger
  id: epy_block
  parameters:
    _source_code: |
      # SPDX-License-Identifier: GPL-3.0
      """Source code also embedded in full_simulation.grc. Ledger is a local mock."""
      import csv
      import hashlib
      import json
      from pathlib import Path
      import uuid
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Window-end decisions, OR/AND fusion, metrics and hash-linked local ledger."""

          def __init__(self, sample_rate=2000000, segment_samples=20000,
                       window_samples=1000, guard_samples=2000,
                       threshold1=0.05, threshold2=0.05, fusion_rule='OR',
                       output_root='simulation/generated', config=None):
              gr.sync_block.__init__(self, name='Fusion, metrics and MOCK ledger',
                                     in_sig=[np.float32] * 5, out_sig=None)
              if window_samples < 1 or not window_samples <= guard_samples < segment_samples:
                  raise ValueError('Require window <= guard < segment_samples')
              if sample_rate <= 0 or min(threshold1, threshold2) < 0:
                  raise ValueError('Invalid sample rate or threshold')
              if fusion_rule not in ('OR', 'AND'):
                  raise ValueError('fusion_rule must be OR or AND')
              self.fs, self.segment = float(sample_rate), int(segment_samples)
              self.window, self.guard = int(window_samples), int(guard_samples)
              self.thresholds, self.rule = (threshold1, threshold2), fusion_rule
              self.root, self.config = output_root, dict(config or {})
              self.position = 0
              self.counts = {name: dict(tp=0, fp=0, tn=0, fn=0)
                             for name in ('rx1', 'rx2', 'OR', 'AND')}
              self.scenarios = {str(i): {name: dict(tp=0, fp=0, tn=0, fn=0)
                                        for name in self.counts} for i in range(4)}
              self.previous_hash = '0' * 64
              self.records = 0
              self.csv_file = self.ledger_file = None
              self.directory = None

          def start(self):
              # GRC introspects constructors: create files only when execution starts.
              self.directory = Path(self.root) / ('full_sim_' + uuid.uuid4().hex)
              self.directory.mkdir(parents=True, exist_ok=False)
              config = dict(self.config, sample_rate=self.fs, segment_samples=self.segment,
                            window_samples=self.window, guard_samples=self.guard,
                            thresholds=self.thresholds, fusion_rule=self.rule,
                            ledger_mode='LOCAL_MOCK_NOT_BLOCKCHAIN')
              encoded = json.dumps(config, sort_keys=True, separators=(',', ':'))
              self.config_hash = hashlib.sha256(encoded.encode()).hexdigest()
              (self.directory / 'config.json').write_text(encoded + '\n', encoding='utf-8')
              self.csv_file = (self.directory / 'observations.csv').open('w', newline='', encoding='utf-8')
              self.writer = csv.writer(self.csv_file)
              self.writer.writerow(['sample_index', 'sample_time_s', 'scenario', 'truth',
                                    'rx1_filtered', 'rx2_filtered', 'rx1_full', 'rx2_full',
                                    'rx1_decision', 'rx2_decision', 'OR', 'AND', 'selected'])
              self.ledger_file = (self.directory / 'mock_ledger.jsonl').open('w', encoding='utf-8')
              print('Simulation outputs:', self.directory)
              return True

          @staticmethod
          def update(counts, decision, truth):
              key = ('tp' if truth else 'fp') if decision else ('fn' if truth else 'tn')
              counts[key] += 1

          def work(self, input_items, output_items):
              n = len(input_items[0])
              # Input order: filtered RX1/RX2, unfiltered RX1/RX2, ideal truth.
              for local in range((-self.position + self.window - 1) % self.window, n, self.window):
                  index = self.position + local
                  if index % self.segment < self.guard:
                      continue  # Exclude FIR/window transients after every scenario change.
                  powers = [float(stream[local]) for stream in input_items[:4]]
                  if not np.all(np.isfinite(powers)):
                      raise ValueError('Nonfinite power observation')
                  truth = int(input_items[4][local] >= 0.5)
                  decisions = [int(powers[i] > self.thresholds[i]) for i in range(2)]
                  either, both = int(any(decisions)), int(all(decisions))
                  scenario = (index // self.segment) % 4
                  for name, decision in zip(self.counts, decisions + [either, both]):
                      self.update(self.counts[name], decision, truth)
                      self.update(self.scenarios[str(scenario)][name], decision, truth)
                  selected = either if self.rule == 'OR' else both
                  self.writer.writerow([index, index / self.fs, scenario, truth,
                                        *powers, *decisions, either, both, selected])
                  record = dict(sequence=self.records, sample_index=index, truth=truth,
                                scenario=int(scenario), powers=powers, decisions=decisions,
                                fusion_rule=self.rule, fused=selected, config_sha256=self.config_hash,
                                previous_hash=self.previous_hash, mode='LOCAL_MOCK_NOT_BLOCKCHAIN')
                  canonical = json.dumps(record, sort_keys=True, separators=(',', ':'))
                  self.previous_hash = hashlib.sha256(canonical.encode()).hexdigest()
                  record['hash'] = self.previous_hash
                  self.ledger_file.write(json.dumps(record, sort_keys=True) + '\n')
                  self.records += 1
              self.position += n
              return n

          @staticmethod
          def metrics(counts):
              tp, fp, tn, fn = (counts[k] for k in ('tp', 'fp', 'tn', 'fn'))
              return dict(counts, probability_detection=tp / (tp + fn) if tp + fn else None,
                          probability_false_alarm=fp / (fp + tn) if fp + tn else None)

          def stop(self):
              if self.directory is not None:
                  expected = int(self.config.get('expected_samples', 0))
                  summary = dict(samples_consumed=self.position, expected_samples=expected,
                                 completed=(self.position == expected) if expected else None,
                                 observations=self.records, final_mock_hash=self.previous_hash,
                                 metrics={k: self.metrics(v) for k, v in self.counts.items()},
                                 per_scenario={s: {k: self.metrics(v) for k, v in nodes.items()}
                                               for s, nodes in self.scenarios.items()},
                                 limitations=['Simulation only; no RF validation',
                                              'Ideal synchronized reporting, no packet loss or network model',
                                              'Local hash chain, no consensus, contract or blockchain network',
                                              'Window observations overlap in filter memory; no confidence intervals'])
                  (self.directory / 'summary.json').write_text(json.dumps(summary, indent=2) + '\n', encoding='utf-8')
                  self.csv_file.close()
                  self.ledger_file.close()
              return True
    sample_rate: samp_rate
    segment_samples: segment_samples
    window_samples: window_samples
    guard_samples: guard_samples
    threshold1: threshold1
    threshold2: threshold2
    fusion_rule: fusion_rule
    output_root: output_root
    config: run_config
  states: {}

connections:
- [scenario_source, '0', rx1_filter, '0']
- [rx1_filter, '0', rx1_filtered_mag2, '0']
- [rx1_filtered_mag2, '0', rx1_filtered_average, '0']
- [rx1_filtered_average, '0', rx1_filtered_scale, '0']
- [rx1_filtered_scale, '0', fusion_logger, '0']
- [scenario_source, '0', rx1_full_mag2, '0']
- [rx1_full_mag2, '0', rx1_full_average, '0']
- [rx1_full_average, '0', rx1_full_scale, '0']
- [rx1_full_scale, '0', fusion_logger, '2']
- [scenario_source, '1', rx2_filter, '0']
- [rx2_filter, '0', rx2_filtered_mag2, '0']
- [rx2_filtered_mag2, '0', rx2_filtered_average, '0']
- [rx2_filtered_average, '0', rx2_filtered_scale, '0']
- [rx2_filtered_scale, '0', fusion_logger, '1']
- [scenario_source, '1', rx2_full_mag2, '0']
- [rx2_full_mag2, '0', rx2_full_average, '0']
- [rx2_full_average, '0', rx2_full_scale, '0']
- [rx2_full_scale, '0', fusion_logger, '3']
- [scenario_source, '2', fusion_logger, '4']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
